Commit message: changed parameters

File: urdf/robotCar.urdf (robot description, URDF)
Before this commit: robot myfirst, 5 links, 4 joints
Links:
- added link base_footprint
Joints:
- added joint base_joint: type fixed, parent base_footprint, child base_link, origin xyz=0 0 0 rpy=0 0 0
